# Only build sgdisk, skip cgdisk (requires ncurses)
PACKAGECONFIG = "popt"
